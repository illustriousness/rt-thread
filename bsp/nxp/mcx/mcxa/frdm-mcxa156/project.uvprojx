# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6190000::V6.19::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.19.0.0
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, RT_USING_ARMLIBC, LFS_CONFIG=lfs_config.h, __CLK_TCK=RT_TICK_PER_SECOND, DEBUG, __STDC_LIMIT_MACROS, CPU_MCXA156VLL, RT_USING_LIBC
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\finsh;applications;..\..\..\..\..\components\drivers\usb\cherryusb\class\dfu;board\ports\cherryusb;..\..\..\..\..\components\drivers\usb\cherryusb\class\adb;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\net\sal\include;..\..\..\..\..\components\net\sal\include\socket;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\sal\include\dfs_net;..\..\..\..\..\components\drivers\usb\cherryusb\core;..\Libraries\drivers\config;..\..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\hub;..\..\..\..\..\components\net\sal\impl;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\..\..\components\drivers\usb\cherryusb;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\serial;board\MCUX_Config\board;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\fal\inc;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\drivers\usb\cherryusb\osal;..\..\..\..\..\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\..\..\components\drivers\smp_call;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\port;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\wifi;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\libc\posix\ipc;..\Libraries\drivers;packages\nxp-mcx-cmsis-latest\Core\Include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\lwip\port;..\..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\..\components\libc\compilers\common\extension;board;packages\nxp-mcx-series-latest\MCXA156\middleware\sdmmc\inc;board\ports\fal;packages\nxp-mcx-series-latest\MCXA156;..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\components\libc\posix\io\poll;packages\littlefs;packages\nxp-mcx-series-latest\MCXA156\components\codec;..\..\..\..\..\components\utilities\ymodem;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\include;board\ports;..\..\..\..\..\components\net\lwip-dhcpd;..\..\..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\net;packages\nxp-mcx-series-latest\MCXA156\drivers;.;..\..\..\..\..\components\drivers\usb\cherryusb\class\hid;..\..\..\..\..\components\drivers\usb\cherryusb\class\cdc;..\..\..\..\..\components\drivers\usb\cherryusb\common;..\..\..\..\..\components\libc\posix\io\epoll
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: main.c fal_test.c
  group CherryUSB
    ../../../../../components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    ../../../../../components/drivers/usb/cherryusb/demo/: cdc_rndis_template.c
    ../../../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../../../components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../../../../components/drivers/usb/cherryusb/port/kinetis/: usb_dc_kinetis.c usb_glue_mcx.c
    ../../../../../components/drivers/usb/cherryusb/class/wireless/: usbd_rndis.c
  group cherryusb-port
    board/ports/cherryusb/: cherryusb.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/mtd/: mtd_nor.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    board/ports/: drv_spi_sample_rw007.c i2c_diag.c p3t1755_sample.c
    board/ports/fal/: fal_flash_port.c fal_fs_init.c
    ../Libraries/drivers/: drv_i2c.c drv_p3t1755.c drv_pin.c drv_spi.c drv_uart.c drv_usb.c
  group Fal
    ../../../../../components/fal/src/: fal_flash.c fal_partition.c fal_rtt.c fal.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/src/: dfs_file.c dfs.c dfs_posix.c dfs_fs.c
  group Finsh
    ../../../../../components/finsh/: msh.c cmd.c shell.c msh_file.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstdio.c rt_vsnprintf_std.c kstring.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA156/arm/: startup_MCXA156.s
    packages/nxp-mcx-series-latest/MCXA156/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA156/: system_MCXA156.c
  group littlefs
    packages/littlefs/: lfs.c lfs_util.c lfs_crc.c dfs_lfs.c
  group lwIP
    ../../../../../components/net/lwip-dhcpd/: dhcp_server_raw.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ymodem/: ymodem.c
